IMAGE_INSTALL_append = "nano python-pyserial git python python-dbus packagegroup-core-ssh-openssh screen"
IMAGE_INSTALL_append = " pythonTTT"